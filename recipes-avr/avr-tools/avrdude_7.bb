require avrdude.inc

SRCREV = "e599214c9d602ca5ae3450fc23bdaf4266562282"
PV = "7.3+git${SRCPV}"
