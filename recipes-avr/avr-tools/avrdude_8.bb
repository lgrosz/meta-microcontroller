require avrdude.inc

SRCREV = "d8c8cf1379c474aee1cc8685b9ec7da71feb8e2a"
PV = "8.0+git${SRCPV}"
